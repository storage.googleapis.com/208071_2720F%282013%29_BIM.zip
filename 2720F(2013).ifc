Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-03-21T13:49:23
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 21 13:49:23 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{6D4FD20E-996C-4D1F-9A89-AB6326CF6AF7}\ifc * Database version: 5507 * Database creation date: Mon Mar 21 13:49:21 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 21 13:49:21 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 21 13:49:21 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 2720F Kitchen faucet, 3 V, 2720F(2013):2720F Kitchen faucet, 3 V:422982
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 255.5 mm; NominalHeight: 293.5 mm; NominalWidth: 122 mm
Type - Electrical Engineering - Battery: AA 1.5 V Lithium x 2; Operating Voltage: 3 V; Protection Class: IP 54
Type - General - Author: BIMStone; BIMObjectName: 2720F(2013); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/03/2022
Type - Green Building Properties - Approval KIWA SE Type Approval: 1462; EAN Number: 6414150070037; EMC Directive: 2014/30/EU , 2011/65/EU; EN Standard: EN 15091 , EN 817; ETIM Class Number: EC011431 Kitchen mixing tap; LVI Number: 6219073; Noise Class: I (ISO 3822); NRF Number: 4200374; RSK Number: 8553477; Sales Package dimensions (LxWxH): 460 x 300 x 130; Sales Package gross weight: 3.62 kg; Sales Package package weight: 0.654133 kg; Sintef Certificate: Sintef Nr. 3083; STF Certificate: EUFI29-20002662-TH2; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.oras.com/DoC/2720F; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/2720F/original; URL REACH: http://static.oras.com/doc/reach; URL SINTEF: http://static.oras.com/Sintef/2720F/original; URL STF: http://static.oras.com/STF/2720F/original; URL UN38.3: http://static.oras.com/UN383/2720F; URL WEEE: http://static.oras.com/WEEE/2720F; VVS Number: 705682504
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/2720F; Catalog Drawing URL: http://static.oras.com/catdrw/2720F; Dimension Drawing URL: http://static.oras.com/dimdrw/2720F; FDV Document URL: http://www.oras.com/datasheet/2720F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/2720F; Group: Kitchen faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/2720F; Interactive AR View URL: https://static.oras.com/AR/2720F; Item Type: Sales item; Long Marketing: Kitchen faucet with easy-grip levers for hot and cold water, touchless function, high swivel spout and aerator. The flow-rate of hot and cold water is adjusted by separate levers. Spout’s swing angle is factory preset at 120° (can be limited to 60° or 80°). The touchless function is turned on by taking hands within the recognition range. The water temperature for the touchless function is adjusted by turning the ring between the faucet and the spout. Touchless function can be easily switched on/off. Battery operated, 3 V. The faucet is equipped with litter filters. F = with flexible pipes; Manufacturer: Oras; Market: International;Denmark;Estonia;Finland;Latvia;Lithuania;Norway;Poland;Russia;Sweden;Ukraine; Mobile Product Information URL: http://mpi.oras.com/2720F; Model: 2720F Kitchen faucet, 3 V; Name_en: 2720F Kitchen faucet, 3 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2720F; Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/2720F; Product URL: http://static.oras.com/2720F; Spare-Part Information URL: http://static.oras.com/sp/2720F; Technical DataSheet URL: http://www.oras.com/datasheet/2720F/en; Type Name: 2720F Kitchen faucet, 3 V; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass;Surfaces in contact with drinking water contain less than 0.3% lead;Waterways without nickel coating; Aerator: Standard aerator; Afterflow Period: 4 s; Automatic Flush Frequency: off; Automatic Flush Period: 30 s; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Electronic Parts: Autofocus infrared sensor;Solenoid valve;Light indicated function(s);Low battery indicator; Flow Rate At 300kPa: 0.000706293 m3/s; Installation Type: Deck mounted; Lever Handle: Two operating levers/handles;Easy-Grip surface; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 40 s; Mechanical Parts: Ceramic head part for flow control;Mixing valve for manual temperature control;Litter filter(s); Mounting Holes: 1 hole; Operating Distance: 0-40 mm; Pressure Loss With Flow 02ls: 290000 Pa; Spout Projection: 193 mm; Spout Swivel Range: 120° (80° / 60°); Spout Type: Swivel spout;Swivel range limiting option; Surface treatment: Chrome; Working Pressure: 100 - 1000 kPa
Type - Other - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Kitchen; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2720F(2013); Features: Hybrid;Battery-operated; Finish: Polished; Grade: n/a; Material: brassPlastic; ModelNumber: n/a; ModelReference: 2720F; Name: 2720F Kitchen faucet, 3 V; ReplacementCost: n/a; Shape: Sculptured; Size: 120x255x300 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2720F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2720F Kitchen faucet, 3 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.143067 m2; Volume: 0.0091534 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 2720F(2013): 2720F Kitchen faucet, 3 V; Family and Type: 2720F(2013): 2720F Kitchen faucet, 3 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2720F(2013): 2720F Kitchen faucet, 3 V; Type Id: 2720F(2013): 2720F Kitchen faucet, 3 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
